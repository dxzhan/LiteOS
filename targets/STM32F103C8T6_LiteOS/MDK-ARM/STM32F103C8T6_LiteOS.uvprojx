# Keil uVision project STM32F103C8T6_LiteOS.uvprojx, settings and files
target STM32F103C8T6_LiteOS (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: STM32F103C8T6_LiteOS +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xB,USE_HAL_DRIVER,STM32F103xB,LOS_KERNEL_DEBUG_OUT
  c include: ../Inc;   ../Drivers/STM32F1xx_HAL_Driver/Inc;   ../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;   ../Drivers/CMSIS/Device/ST/STM32F1xx/Include;   ../Drivers/CMSIS/Include;   ..\OS_CONFIG;   ..\Middlewares\LiteOS\arch\arm\arm-m\include;   ..\Middlewares\LiteOS\kernel\include;   ..\Middlewares\LiteOS\kernel\base\include;   ..\Middlewares\LiteOS\kernel\extended\include;   ..\Middlewares\LiteOS\demos\kernel\include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application/MDK-ARM
    ./: startup_stm32f103xb.s
  group Application/User
    ../Src/: main.c gpio.c usart.c stm32f1xx_it.c stm32f1xx_hal_msp.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c
  group Drivers/CMSIS
    ../Src/: system_stm32f1xx.c
  group Middlewares/LiteOS/arch
    ../Middlewares/LiteOS/arch/arm/arm-m/src/: los_hw.c los_hw_tick.c los_hwi.c
    ../Middlewares/LiteOS/arch/arm/arm-m/cortex-m3/keil/: los_dispatch_keil.S
  group Midllewares/LiteOS/kernel
    ../Middlewares/LiteOS/kernel/: los_init.c
    ../Middlewares/LiteOS/kernel/base/core/: los_priqueue.c los_swtmr.c los_sys.c los_task.c los_tick.c los_timeslice.c
    ../Middlewares/LiteOS/kernel/base/ipc/: los_event.c los_mux.c los_queue.c los_sem.c
    ../Middlewares/LiteOS/kernel/base/mem/bestfit_little/: los_heap.c los_memory.c
    ../Middlewares/LiteOS/kernel/base/mem/common/: los_memcheck.c los_memstat.c los_slab.c los_slabmem.c
    ../Middlewares/LiteOS/kernel/base/mem/membox/: los_membox.c
    ../Middlewares/LiteOS/kernel/base/misc/: los_misc.c
    ../Middlewares/LiteOS/kernel/base/om/: los_err.c
    ../Middlewares/LiteOS/kernel/extended/tickless/: los_tickless.c
  group Middlewares/LiteOS/demos
    ../Middlewares/LiteOS/demos/kernel/api/: los_api_dynamic_mem.c los_api_event.c los_api_interrupt.c los_api_list.c los_api_msgqueue.c los_api_mutex.c los_api_sem.c los_api_static_mem.c los_api_systick.c los_api_task.c los_api_timer.c los_demo_entry.c los_inspect_entry.c
software components: CMSIS:CORE 5.2.0
